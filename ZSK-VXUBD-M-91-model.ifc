Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:22+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-VXUBD-M-91
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-VXUBD-M-91 Вазон «Ротонда» · мрамор «шахматка»
In: Площадка
Description: Изделие бетонное благоустройства. Вазон «Ротонда» · мрамор «шахматка»; Classification: 05.3.02.03 Вазон уличный (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-VXUBD-M-91; ModelReference: Вазон «Ротонда» · мрамор «шахматка»; ProductionYear: 2026; ArticleNumber: ZSK-VXUBD-M-91
ORION_Изделие - Артикул: ZSK-VXUBD-M-91; Артикул прежний: SD-VXUBD-M-91; Наименование: Вазон «Ротонда» · мрамор «шахматка»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 350×460×550 мм; Материал: Бетон; Цена: 32 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20801; Код КСИ: CPr>EDG010; Класс КСИ: Вазон уличный; Коды КСР: 05.3.02.03 … 59.1.15.02-0449
ADSK - ADSK_Наименование: Вазон «Ротонда» · мрамор «шахматка»; ADSK_Марка: ZSK-VXUBD-M-91; ADSK_Код изделия: 05.3.02.03; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20801
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDG010; ZSK_Артикул_прежний: SD-VXUBD-M-91
Qto_ORION - Длина: 350 mm; Ширина: 460 mm; Высота: 550 mm
